# Keil uVision project MyBeat_V3.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.29.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: DEBUG APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD MBEDTLS_CONFIG_FILE=<nrf_crypto_mbedtls_config.h> NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_CRYPTO_MAX_INSTANCE_COUNT=1 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\config;..\..\components;..\..\components\ble\ble_advertising;..\..\components\ble\ble_dtm;..\..\components\ble\ble_racp;..\..\components\ble\ble_services\ble_ancs_c;..\..\components\ble\ble_services\ble_ans_c;..\..\components\ble\ble_services\ble_bas;..\..\components\ble\ble_services\ble_bas_c;..\..\components\ble\ble_services\ble_cscs;..\..\components\ble\ble_services\ble_cts_c;..\..\components\ble\ble_services\ble_dfu;..\..\components\ble\ble_services\ble_dis;..\..\components\ble\ble_services\ble_gls;..\..\components\ble\ble_services\ble_hids;..\..\components\ble\ble_services\ble_hrs;..\..\components\ble\ble_services\ble_hrs_c;..\..\components\ble\ble_services\ble_hts;..\..\components\ble\ble_services\ble_ias;..\..\components\ble\ble_services\ble_ias_c;..\..\components\ble\ble_services\ble_lbs;..\..\components\ble\ble_services\ble_lbs_c;..\..\components\ble\ble_services\ble_lls;..\..\components\ble\ble_services\ble_nus;..\..\components\ble\ble_services\ble_nus_c;..\..\components\ble\ble_services\ble_rscs;..\..\components\ble\ble_services\ble_rscs_c;..\..\components\ble\ble_services\ble_tps;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\nrf_ble_qwr;..\..\components\ble\peer_manager;..\..\components\boards;..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\bootloader\ble_dfu;..\..\components\libraries\bsp;..\..\components\libraries\button;..\..\components\libraries\cli;..\..\components\libraries\crc16;..\..\components\libraries\crc32;..\..\components\libraries\crypto;..\..\components\libraries\crypto\backend\cc310;..\..\components\libraries\crypto\backend\cc310_bl;..\..\components\libraries\crypto\backend\cifra;..\..\components\libraries\crypto\backend\mbedtls;..\..\components\libraries\crypto\backend\micro_ecc;..\..\components\libraries\crypto\backend\nrf_hw;..\..\components\libraries\crypto\backend\nrf_sw;..\..\components\libraries\crypto\backend\oberon;..\..\components\libraries\crypto\backend\optiga;..\..\components\libraries\csense;..\..\components\libraries\csense_drv;..\..\components\libraries\delay;..\..\components\libraries\ecc;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\experimental_task_manager;..\..\components\libraries\fds;..\..\components\libraries\fstorage;..\..\components\libraries\gfx;..\..\components\libraries\gpiote;..\..\components\libraries\hardfault;..\..\components\libraries\hci;..\..\components\libraries\led_softblink;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\low_power_pwm;..\..\components\libraries\mem_manager;..\..\components\libraries\memobj;..\..\components\libraries\mpu;..\..\components\libraries\mutex;..\..\components\libraries\pwm;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\queue;..\..\components\libraries\ringbuf;..\..\components\libraries\scheduler;..\..\components\libraries\sdcard;..\..\components\libraries\sensorsim;..\..\components\libraries\slip;..\..\components\libraries\sortlist;..\..\components\libraries\spi_mngr;..\..\components\libraries\stack_guard;..\..\components\libraries\stack_info;..\..\components\libraries\strerror;..\..\components\libraries\svc;..\..\components\libraries\timer;..\..\components\libraries\twi_mngr;..\..\components\libraries\twi_sensor;..\..\components\libraries\usbd;..\..\components\libraries\usbd\class\audio;..\..\components\libraries\usbd\class\cdc;..\..\components\libraries\usbd\class\cdc\acm;..\..\components\libraries\usbd\class\hid;..\..\components\libraries\usbd\class\hid\generic;..\..\components\libraries\usbd\class\hid\kbd;..\..\components\libraries\usbd\class\hid\mouse;..\..\components\libraries\usbd\class\msc;..\..\components\libraries\util;..\..\components\nfc\ndef\conn_hand_parser;..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\components\nfc\ndef\connection_handover\common;..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\components\nfc\ndef\generic\message;..\..\components\nfc\ndef\generic\record;..\..\components\nfc\ndef\launchapp;..\..\components\nfc\ndef\parser\message;..\..\components\nfc\ndef\parser\record;..\..\components\nfc\ndef\text;..\..\components\nfc\ndef\uri;..\..\components\nfc\platform;..\..\components\nfc\t2t_lib;..\..\components\nfc\t2t_parser;..\..\components\nfc\t4t_lib;..\..\components\nfc\t4t_parser\apdu;..\..\components\nfc\t4t_parser\cc_file;..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\components\nfc\t4t_parser\tlv;..\..\components\softdevice\common;..\..\components\softdevice\s332\headers;..\..\components\softdevice\s332\headers\nrf52;..\..\external\fprintf;..\..\external\mbedtls\include;..\..\external\nrf_cc310\include;..\..\external\nrf_oberon;..\..\external\nrf_oberon\include;..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\external\segger_rtt;..\..\external\utf_converter;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\hal;..\config;..\Inc;..\..\components\libraries\bootloader\dfu;..\..\components\libraries\bootloader;..\..\module\nrfx\mdk;..\..\components\ant\ant_channel_config;..\..\components\ant\ant_key_manager;..\..\components\ant\ant_key_manager\config;..\..\components\ant\ant_profiles\ant_hrm;..\..\components\ant\ant_profiles\ant_hrm\pages;..\..\components\ant\ant_profiles\ant_hrm\simulator;..\..\components\ant\ant_profiles\ant_hrm\utils;..\..\components\ant\ant_state_indicator;..\MDK-ARM;..\MDK-ARM;..\MDK-ARM;..\MDK-ARM;..\..\components\libraries\uart
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_CRYPTO_MAX_INSTANCE_COUNT=1 NRF_SD_BLE_API_VERSION=7 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_CRYPTO_MAX_INSTANCE_COUNT=1,-DNRF_SD_BLE_API_VERSION=7,-DS132,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_gatt;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\atomic_flags;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\..\components\libraries\crypto\backend\optiga;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\svc;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\components\nfc\ndef\launchapp;..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\components\nfc\ndef\text;..\..\..\..\..\..\components\nfc\ndef\uri;..\..\..\..\..\..\components\nfc\platform;..\..\..\..\..\..\components\nfc\t2t_lib;..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\components\nfc\t4t_lib;..\..\..\..\..\..\components\nfc\t4t_parser\apdu;..\..\..\..\..\..\components\nfc\t4t_parser\cc_file;..\..\..\..\..\..\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\..\..\..\components\nfc\t4t_parser\tlv;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\mbedtls\include;..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\utf_converter;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002bf0 size 0xd410
  scatter file: .\_build\nrf52832_xxaa.sct
  link misc: --any_placement best_fit --show-parent-lib --show-full-path
  group Application
    ../Src/: main.c lis2dw12_reg.c fxi.c zonas_cardiacas.c Controle_LEDs.c ble_rtcs.c ble_rus.c ble_uds.c buffer_services.c reamostragem.c
    ../config/: sdk_config.h
    ./: fxi_image.s ble_rsc.c ble_rsc.h ble_cscs.c ble_cscs.h ads018.c mma8653.h filter.c pstorage_platform.h filter.h Cycle.h pstorage.h acceleration.h trigonometry.h heritage.h
  group Board Definition
    ../../components/boards/: boards.c
  group Board Support
    ../../components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group UTF8/UTF16 converter
    ../../external/utf_converter/: utf.c
  group nRF_BLE
    ../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_lesc.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ./: ble_sc_ctrlpt.c
  group nRF_Crypto
    ../../components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_aes.c nrf_crypto_aes_shared.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_eddsa.c nrf_crypto_error.c nrf_crypto_hash.c nrf_crypto_hkdf.c nrf_crypto_hmac.c nrf_crypto_init.c nrf_crypto_rng.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend nRF HW
    ../../components/libraries/crypto/backend/nrf_hw/: nrf_hw_backend_init.c nrf_hw_backend_rng.c nrf_hw_backend_rng_mbedtls.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_rng.c nrf_drv_uart.c nrf_drv_spi.c
    ../../modules/nrfx/soc/: nrfx_atomic.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_rng.c nrfx_uart.c nrfx_uarte.c nrfx_spim.c nrfx_spi.c nrfx_pwm.c nrfx_saadc.c nrfx_wdt.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../components/libraries/crc16/: crc16.c
    ../../components/libraries/fds/: fds.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/mem_manager/: mem_manager.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../components/libraries/queue/: nrf_queue.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/sortlist/: nrf_sortlist.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../../external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_3.0.1.lib
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c nrf_sdh_ant.c
  group nRF_TLS
    ../../external/mbedtls/library/: aes.c ctr_drbg.c
  group nrf_cc310
    ../../external/nrf_cc310/lib/cortex-m4/hard-float/short-wchar/: nrf_cc310_0.9.12.lib
  group nRF_DFU
    ../../components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
  group nRF_SVC
    ../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_ANT
    ../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../components/ant/ant_profiles/ant_hrm/: ant_hrm.c
    ../../components/ant/ant_profiles/ant_hrm/pages/: ant_hrm_page_0.c ant_hrm_page_1.c ant_hrm_page_2.c ant_hrm_page_3.c ant_hrm_page_4.c
    ../../components/ant/ant_key_manager/: ant_key_manager.c
    ../../components/ant/ant_state_indicator/: ant_state_indicator.c
    ../../components/ant/ant_profiles/ant_hrm/simulator/: ant_hrm_simulator.c
    ../Src/: ant_hrm_measurement.c hr_measurement.c
target flash_s132_nrf52_7.0.1_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.29.0
  cpu: as above
  output: s132_nrf52_7.0.1_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002bd0 size 0xd430
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.4.0, CMSIS:CORE 4.3.0, Device:Startup 8.29.0, Device:Startup 8.32.1, Device:StartupConfig 8.29.0, Device:StartupConfig 8.32.1
